# Keil uVision project swithc_froster.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: swithc_froster +hex
  AfterMake: C:\Keil_v5\ARM\ARMCLANG\bin\fromelf.exe --bin C:\freezer\freezer-board\SwithcFrost\objects\swithc_froster.axf --output bin\\switch_frost.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=5 wLevel=1
  c define: STM32F10X_MD USE_STDPERIPH_DRIVER
  c include: .\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\STM32F10x_StdPeriph_Driver\src;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\USB\STM32_USB-FS-Device_Driver\inc;.\USB\STM32_USB-FS-Device_Driver\src;.\USB\inc;.\USB\src;.\SPI2;.\I2C;.\Sources;.\Sources\AT24C32_source;.\Encoder;..\P_regulator;..\P_regulator\Objects;.\FontsRus;.\1306
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USB
    ./USB/inc/: HidDev_Config.h hw_config.h platform_config.h stm32_it.h usb_conf.h usb_desc.h usb_istr.h usb_prop.h usb_pwr.h
    ./USB/src/: hw_config.c stm32_it.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
    ./USB/STM32_USB-FS-Device_Driver/inc/: usb_core.h usb_def.h usb_init.h usb_type.h usb_int.h usb_lib.h usb_mem.h usb_regs.h usb_sil.h
    ./USB/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group STM32F10x_StdPeriph_Lib
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group 1306
    ./1306/: ssd1306.c ssd1306_i2c.c fonts.c ssd1306.h
    ./FontsRus/: OLED.c OLED.h OLED_Fonst.c OLED_Fonts.h
  group Sources
    ./Sources/: main.c onewire.c i2c.c bkp.h onewire.h i2c.h main.h onewire2.c onewire2.h SysTimer.c SysTimer.h flash.c
    ./Sources/AT24C32_source/: AT24C02.c AT24C02.h eeprom.h
    ./Encoder/: encodeTIM2_PA0_PA1r.c
  group SPI2
    ./SPI2/: spi2_new.c spi2_new.h
  group P_reg
    ../P_regulator/: Preg.c Preg.h
software components: CMSIS:CORE 5.6.0
